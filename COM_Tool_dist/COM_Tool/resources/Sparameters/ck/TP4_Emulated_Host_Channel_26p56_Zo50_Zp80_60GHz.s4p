! Created Tue Jul 20 18:34:21 2021
# hz S ma R 50
! 4 Port Network Data from SP1.SP block
! freq  magS11  angS11  magS12  angS12  magS13  angS13  magS14  angS14
!  magS21  angS21  magS22  angS22  magS23  angS23  magS24  angS24
!  magS31  angS31  magS32  angS32  magS33  angS33  magS34  angS34
!  magS41  angS41  magS42  angS42  magS43  angS43  magS44  angS44
! Worked out from all points (differential pair):
!   6000 points, 10 MHz to 60 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 15.01 GHz, 30.01 GHz, 45.01 GHz, 60 GHz:
!     S43: 0.0, -2.0, -3.5, -4.8, -6.1
!     S21: 0.0, -2.0, -3.5, -4.8, -6.1
!     S42: -, -, -, -, -
!     S41: -, -, -, -, -
!     S32: -, -, -, -, -
!     S31: -, -, -, -, -
!   taken as a pair (ports 3,1 in; 4,2 out), SDD21 dB: 0.0, -2.0, -3.5, -4.8, -6.1
!   lowest |S11| = - dB at 10 MHz (marker M1), VSWR 1.00, Z = 50 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S43  S21
! 10 MHz  0.0  0.0
! 1.51 GHz  -0.4  -0.4
! 4.62 GHz  -0.9  -0.9
! 9.51 GHz  -1.5  -1.5
! 16.16 GHz  -2.1  -2.1
! 35.06 GHz  -3.9  -3.9
! 60 GHz  -6.1  -6.1
