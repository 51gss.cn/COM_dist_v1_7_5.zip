! Created Mon Mar 16 19:29:21 2020
# hz S DB R 50
! 4 Port Network Data from SP1.SP block
! freq  magS11  angS11  magS12  angS12  magS13  angS13  magS14  angS14
!  magS21  angS21  magS22  angS22  magS23  angS23  magS24  angS24
!  magS31  angS31  magS32  angS32  magS33  angS33  magS34  angS34
!  magS41  angS41  magS42  angS42  magS43  angS43  magS44  angS44
! Worked out from all points (4-port):
!   2000 points, 50 MHz to 100 GHz, reference 50 ohm
!   strongest paths, dB at 50 MHz, 25.05 GHz, 50.05 GHz, 75.05 GHz, 100 GHz:
!     S43: 0.0, -1.4, -2.4, -3.4, -4.4
!     S21: 0.0, -1.4, -2.4, -3.4, -4.4
!     S42: -100.0, -100.0, -100.0, -100.0, -100.0
!     S41: -100.0, -100.0, -100.0, -100.0, -100.0
!     S32: -100.0, -100.0, -100.0, -100.0, -100.0
!     S31: -100.0, -100.0, -100.0, -100.0, -100.0
!   lowest |S11| = -100.0 dB at 50 MHz (marker M1), VSWR 1.00, Z = 50 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S42  S41  S32  S31
! 50 MHz  -100.0  0.0  0.0  -100.0  -100.0  -100.0  -100.0
! 2.8 GHz  -100.0  -0.3  -0.3  -100.0  -100.0  -100.0  -100.0
! 8.1 GHz  -100.0  -0.6  -0.6  -100.0  -100.0  -100.0  -100.0
! 16.35 GHz  -100.0  -1.0  -1.0  -100.0  -100.0  -100.0  -100.0
! 27.5 GHz  -100.0  -1.5  -1.5  -100.0  -100.0  -100.0  -100.0
! 59.3 GHz  -100.0  -2.8  -2.8  -100.0  -100.0  -100.0  -100.0
! 100 GHz  -100.0  -4.4  -4.4  -100.0  -100.0  -100.0  -100.0
